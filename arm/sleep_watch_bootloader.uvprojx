# Keil uVision project sleep_watch_bootloader.uvprojx, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: sleep_watch_bootloader +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BOARD_PCA10001, BOOTLOADER_BANKED BLE_STACK_SUPPORT_REQD,ENABLE_DEBUG_LOG_SUPPORT
  c include: ..;..\User\inc;..\User\inc\ble_transport;..\Include;..\Include\sd_common;..\Include\app_common;..\Include\ble;..\Include\ble\ble_services;..\Include\s110
  memory RVCT4: ROM 0x3c000 size 0x4000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Source Code
    ../User/src/: main.c dfu_dual_bank.c bootloader.c bootloader_util_arm.c
  group Services
    ../Source/ble/ble_services/: ble_dfu.c
  group Libraries
    ../Source/app_common/: app_timer.c app_scheduler.c app_gpiote.c crc16.c pstorage.c app_trace.c
    ../Source/sd_common/: softdevice_handler.c
    ../Source/simple_uart/: simple_uart.c
  group HCI Transport
    ../Source/app_common/: hci_mem_pool.c
  group BLE Transport
    ../User/src/: dfu_transport_ble.c
    ../Source/ble/: ble_conn_params.c ble_advdata.c
    ../Source/ble/ble_services/: ble_srv_common.c
software components: CMSIS:CORE 5.0.2, Device:Startup 8.14.1, Device:StartupConfig 8.14.1
